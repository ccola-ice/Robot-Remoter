# Keil uVision project Remoter.uvprojx, settings and files
target Remoter (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Remoter +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4
  c include: ..\4_Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\4_Libraries\CMSIS\Include;..\4_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\1_App;..\7_Test;..\2_Platform;..\3_Protocol\FatFs;..\3_Protocol\nmea_decode\include;..\5_Middleware\MPU6050\eMPL;..\5_Middleware\MultiButton;..\5_Middleware\uGUI;..\5_Middleware\Malloc;..\5_ModuleDrivers;..\5_ModuleDrivers\fonts;..\5_ModuleDrivers\touch;..\5_SystemDrivers;..\6_Core;..\5_Middleware\tjpgd\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../1_App/: main.c gui.c menu.c param.c
  group Test
    ../7_Test/: EEPROM_test.c FLASH_test.c SDCARD_test.c SRAM_test.c LCD_test.c nmea_decode_test.c
  group Platforn
    ../2_Platform/: platform_nrf.c platform_io.c platform_mpu.c platform_sdcard.c
  group Middleware/MPU6050/eMPL
    ../5_Middleware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Middleware/MultiButton
    ../5_Middleware/MultiButton/: multi_button.c multi_button_user.c
  group Middleware/uGUI
    ../5_Middleware/uGUI/: ugui.c
  group Middleware/Malloc
    ../5_Middleware/Malloc/: malloc.c
  group Middleware/jpgLib
    ../5_Middleware/tjpgd/src/: jpgPort.c tjpgd.c
  group Protocal/FatFs
    ../3_Protocol/FatFs/: cc936.c diskio.c ff.c FATFS_SDCARD_test.c FATFS_FLASH_test.c
  group Protocal/nmealib
    ../3_Protocol/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group ModuleDrivers
    ../5_ModuleDrivers/: bsp_gpio_led.c bsp_gpio_button.c bsp_gpio_stick.c bsp_usart_debug.c bsp_usart_gps.c bsp_usart_extra.c bsp_spi_flash.c bsp_spi_nrf.c bsp_i2c_eeprom.c bsp_i2c_touch.c bsp_i2c_mpu6050.c bsp_mpu6050.c bsp_mpu6050_exti.c bsp_adc1_independent_dual.c bsp_adc3_independent_dual.c bsp_general_tim2.c bsp_general_tim3.c bsp_general_tim4.c bsp_general_tim5.c bsp_basic_tim6.c bsp_basic_tim7.c bsp_sdio_sd.c bsp_fsmc_sram.c bsp_fsmc_lcd.c bsp_bmp.c
  group ModuleDrivers/Fonts
    ../5_ModuleDrivers/fonts/: fonts.c
  group ModuleDrivers/touch
    ../5_ModuleDrivers/touch/: gt9xx.c palette.c
  group SystemDrivers
    ../5_SystemDrivers/: bsp_SysTick.c bsp_exti.c bsp_rcc.c bsp_rtc.c
  group Libraries
    ../4_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Core
    ../6_Core/: startup_stm32f40xx.s stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c common.c
